# Keil uVision project f4.uvproj, settings and files
target STM32F4xx_Debug (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: f4 +hex
  c flags: Optim=3 OneElfS=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,USE_USB_OTG_HS,USE_USB_OTG_FS
  c include: ..\inc;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\Libraries\STM32_USB_OTG_Driver\inc;..\..\Libraries\STM32_USB_Device_Library\Core\inc;..\..\Libraries\STM32_USB_Device_Library\Class\cdc\inc;..\..\Libraries\STM32_USB_Device_Library\Class\hid\inc;..\dfu;..\..\sample;..\..\configure;..\..\protocol
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000010 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group APP
    ../src/: app.c stm32fxxx_it.c usb_bsp.c usbd_cdc_vcp.c usbd_vcp_desc.c usbd_hid_desc.c usbd_usr.c usbd_fifo.c
  group STM32F4xx
    ../src/: system_stm32f4xx.c startup_stm32f40xx.s
  group stm32f4x_lib
    ../../Libraries/STM32F4xx_StdPeriph_Driver/: stm32f4_std_libc_V4.0.1.lib
  group USB Device
    ../../Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../../Libraries/STM32_USB_Device_Library/Class/hid/src/: usbd_hid_core.c
    ../../Libraries/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
  group USB Driver
    ../../Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
target STM32F4xx_Release (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  cpu: as above
  output: f4
  BeforeMake: run_before.bat
  AfterMake: run_after.bat
  c flags: Optim=3 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,USE_USB_OTG_HS,USE_USB_OTG_FS,USE_BOOTLDR
  c misc: --C99
  c include: ..\inc;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\Libraries\STM32_USB_OTG_Driver\inc;..\..\Libraries\STM32_USB_Device_Library\Core\inc;..\..\Libraries\STM32_USB_Device_Library\Class\cdc\inc;..\..\Libraries\STM32_USB_Device_Library\Class\hid\inc;..\..\sample;..\..\configure;..\dfu
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x100000
  memory RVCT9: RAM 0x20000010 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\f4.sct
